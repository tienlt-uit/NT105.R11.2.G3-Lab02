options:
  parameters:
    generate_options: qt_gui
    id: Cau_7___Square_Synth
    title: Cau 7 - Square Synth
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, distance=1.0, freq=2.4e9, snr_db=30.0):
              gr.sync_block.__init__(
                  self,
                  name='Channel',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.distance = distance
              self.freq = freq
              self.snr_db = snr_db
              self.rng = np.random.default_rng(0)

              # Tính suy hao không gian tự do (FSL)
              c = 299792458.0
              lam = c / freq
              fsl = (4 * np.pi * distance / lam) ** 2 
              
              # THÊM DÒNG NÀY: Hệ số Gain để tín hiệu không bị chìm về 0 trên đồ thị
              Gain = 1000.0 
              
              # Sửa công thức: nhân thêm Gain vào trước khi lấy căn bậc 2
              self.atten = np.sqrt(Gain / fsl) 

          def work(self, input_items, output_items):
              x = input_items[0]
              out = output_items[0]

              # 1. Suy hao tín hiệu
              y = x * self.atten

              # 2. Cộng nhiễu Gauss
              sig_power = np.mean(x ** 2) * self.atten ** 2
              noise_power = sig_power / (10 ** (self.snr_db / 10))
              sigma = np.sqrt(noise_power)
              y = y + self.rng.normal(0.0, sigma, len(y))

              out[:] = y
              return len(out)
    distance: '8'
    freq: 2.4e9
    snr_db: '30.0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    marker1: '-1'
    marker2: '-1'
    name: Spectrum
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    alpha2: '1'
    name: Scope
    nconnections: '2'
    size: '128'
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    yunit: ''
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', epy_block_1, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_1, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
