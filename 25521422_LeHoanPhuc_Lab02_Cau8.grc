options:
  parameters:
    generate_options: qt_gui
    id: Cau_7___Square_Synth
    title: Cau 7 - Square Synth
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, samp_rate=32000, f0=1000, k_max=5, amplitude=1.0):
              gr.sync_block.__init__(
                  self,
                  name='Square Synth',
                  in_sig=None, # Không có cổng vào
                  out_sig=[np.float32]
              )
              self.samp_rate = samp_rate
              self.f0 = f0
              self.k_max = k_max
              self.amplitude = amplitude
              self.phase = 0.0

              # Kiểm tra Nyquist
              if k_max * f0 >= samp_rate / 2:
                  k_max_valid = int((samp_rate / 2) // f0) - 1
                  print(f"CANH BAO: k_max*f0 = {k_max*f0} Hz vuot qua Nyquist! k_max toi da hop le la: {k_max_valid}")

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)
              t = (np.arange(n) + self.phase) / self.samp_rate
              
              # Tính tổng chuỗi Fourier
              s = np.zeros(n, dtype=np.float64)
              for k in range(1, self.k_max + 1, 2): 
                  s += np.sin(2 * np.pi * k * self.f0 * t) / k
                  
              out[:] = self.amplitude * (4 / np.pi) * s
              self.phase += n
              return n
    amplitude: '1'
    f0: '1000'
    k_max: '31'
    samp_rate: '32000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    marker1: '-1'
    marker2: '-1'
    name: Spectrum
    style1: '1'
    style2: '1'
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    autoscale: 'True'
    name: Scope
    size: '128'
    srate: samp_rate
    tr_level: '0'
    tr_tag: ''
    type: float
    update_time: '0.1'
    yunit: ''
  states: {}
- name: wasm_gui_layout_0
  id: wasm_gui_layout
  parameters:
    columns: '12'
    layout: '{}'
    row_height: '60'
  states: {}

connections:
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0
